# Keil uVision project std_103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: std_103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=550,177
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F10x\Include;..\..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F10x/Source/arm/: startup_stm32f10x_hd.s
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/usart/: uart.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../Users/: main.c stm32f10x_it.c
    ../../Drivers/FreeRTOS/: freertos_run.c
    ../../Drivers/CMSIS/Device/ST/STM32F10x/Source/: system_stm32f10x.c
    ../../FreeRTOS/include/: FreeRTOSConfig.h
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/OLED_IIC/: oled.c
    ../../Drivers/BSP/TIMER/: gtim.c
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Config
    ../../Drivers/BSP/TIMER/: tim_config.h
    ../../Drivers/SYSTEM/usart/: uart_config.h
  group Readme
    ../../Drivers/BSP/TIMER/: timx.txt
